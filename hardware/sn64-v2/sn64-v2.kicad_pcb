# Repository FantomZap/SN-64 (continued)

## KiCad design hardware/sn64/sn64.kicad_pcb (continued)

Schematic: fpga.kicad_sch, SN 64 - FPGA

Parts:
C401, C402, C403, C404, C405, C406, C407, C408, C409, C410, C411, C412, C413, C414, C415, C416, C417, C418, C419, C420, C424, C425, C426, C427, C429, C430, C432, C433, C435, C436, C437, C439, C440, C441, C443, C444, C445, C447, C448, C449, C451, C452, C454, C455, C456, C457, C458, C459: 100nF 16V X7R; C_0402_1005Metric
C421, C422, C423, C428, C431, C434, C438, C442, C446, C450, C453: 10uF 10V X5R; C_0603_1608Metric
D401: LED green 0603; LED_0603_1608Metric
FB401: BLM18PG121SN1D; L_0603_1608Metric; LCSC C14709
R401, R402, R403, R404, R407, R410, R411, R412, R413: 4.7k; R_0402_1005Metric
R405: 33; R_0402_1005Metric
R406, R419: 1k; R_0402_1005Metric
R408, R409, R416, R418: 10k; R_0402_1005Metric
R414: 0; R_0402_1005Metric
R415: 100k; R_0402_1005Metric
R417: 33k; R_0402_1005Metric
TP401: PROGRAMN; TestPoint_Pad_D1.0mm
TP402: INITN; TestPoint_Pad_D1.0mm
TP403: DONE; TestPoint_Pad_D1.0mm
TP404: FPGA_1V1; TestPoint_Pad_D1.0mm
TP405: VCCAUX; TestPoint_Pad_D1.0mm
TP406: FPGA_3V3; TestPoint_Pad_D1.0mm
TP407: FLASH_SCK; TestPoint_Pad_D1.0mm
TP408: N64_SW_OE_N; TestPoint_Pad_D1.0mm
U401: LFE5U-85F-6BG381C; Lattice_caBGA-381_17x17mm_Layout20x20_P0.8mm
U402, U403, U404: SN74CB3Q3384APWR; TSSOP-24_4.4x7.8mm_P0.65mm; LCSC C469874
U405: W25Q128JVSIQ; SOIC-8_5.3x5.3mm_P1.27mm; LCSC C97521
U406: SN74LVC1G14DBVR; SOT-23-5; LCSC C7835
U407: SN74LVC1G07DBVR; SOT-23-5; LCSC C7829

Connections:
/FPGA/FPGA_VCCAUX: C424.1, C425.1, C426.1, C427.1, C428.1, FB401.2, TP405.1, U401.F6 (VCCAUX), U401.F15 (VCCAUX), U401.P6 (VCCAUX), U401.P15 (VCCAUX)
/FPGA/flash_cs_n: R407.2, U401.R2 (PB15A), U405.1 (~CS)
/FPGA/flash_dq0: U401.W2 (PB11B), U405.5 (DI/IO_{0})
/FPGA/flash_dq1: U401.V2 (PB11A), U405.2 (DO/IO_{1})
/FPGA/flash_dq2: R408.2, U401.Y2 (PB9B), U405.3 (~WP/IO_{2})
/FPGA/flash_dq3: R409.2, U401.W1 (PB9A), U405.7 (~HOLD/~RESET/IO_{3})
/FPGA/flash_sck: R405.2, R406.2, TP407.1, U405.6 (CLK)
/FPGA/fpga_cfg1: R401.2, U401.T4 (CFG_1)
/FPGA/fpga_done: R404.2, TP403.1, U401.Y3 (DONE)
/FPGA/fpga_initn: R403.2, TP402.1, U401.V3 (~INIT)
/FPGA/fpga_mclk: R405.1, U401.U3 (CCLK)
/FPGA/fpga_n64_ad0: U401.E6 (PT6A), U402.2 (1B1)
/FPGA/fpga_n64_ad1: U401.D6 (PT6B), U402.5 (1B2)
/FPGA/fpga_n64_ad2: U401.E7 (PT9A), U402.6 (1B3)
/FPGA/fpga_n64_ad3: U401.D7 (PT9B), U402.9 (1B4)
/FPGA/fpga_n64_ad4: U401.C6 (PT11A), U402.10 (1B5)
/FPGA/fpga_n64_ad5: U401.C7 (PT11B), U402.15 (2B1)
/FPGA/fpga_n64_ad6: U401.E8 (PT13A), U402.16 (2B2)
/FPGA/fpga_n64_ad7: U401.D8 (PT13B), U402.19 (2B3)
/FPGA/fpga_n64_ad8: U401.C8 (PT15A), U402.20 (2B4)
/FPGA/fpga_n64_ad9: U401.B8 (PT15B), U402.23 (2B5)
/FPGA/fpga_n64_ad10: U401.A7 (PT18A), U403.2 (1B1)
/FPGA/fpga_n64_ad11: U401.A8 (PT18B), U403.5 (1B2)
/FPGA/fpga_n64_ad12: U401.D9 (PT20A), U403.6 (1B3)
/FPGA/fpga_n64_ad13: U401.E9 (PT20B), U403.9 (1B4)
/FPGA/fpga_n64_ad14: U401.C9 (PT54A), U403.10 (1B5)
/FPGA/fpga_n64_ad15: U401.D10 (PT56A), U403.15 (2B1)
/FPGA/fpga_n64_aleh: U401.B9 (PT58A), U403.19 (2B3)
/FPGA/fpga_n64_alel: U401.E10 (PT56B), U403.16 (2B2)
/FPGA/fpga_n64_cic_clk: U401.A10 (PT63A), U404.6 (1B3)
/FPGA/fpga_n64_cic_dq: U401.C11 (PT65B), U404.10 (1B5)
/FPGA/fpga_n64_int_n: U401.B6 (PT4B), U404.16 (2B2)
/FPGA/fpga_n64_nmi_n: U401.A11 (PT63B), U404.5 (1B2)
/FPGA/fpga_n64_read_n: U401.C10 (PT58B), U403.20 (2B4)
/FPGA/fpga_n64_reset_n: U401.B10 (PT60B), U404.2 (1B1)
/FPGA/fpga_n64_si_clk: U401.B11 (PT65A), U404.9 (1B4)
/FPGA/fpga_n64_si_dq: U401.A6 (PT4A), U404.15 (2B1)
/FPGA/fpga_n64_write_n: U401.A9 (PT60A), U403.23 (2B5)
/FPGA/fpga_programn: R402.2, TP401.1, U401.W3 (~PROGRAM), U407.4
/FPGA/host_det: R416.2, R417.1, U406.2
/FPGA/led_a: D401.2 (A), R419.2
/FPGA/led_status: R419.1, U401.B1 (PL35B)
/FPGA/n64_sw_oe_n: R418.2, TP408.1, U402.1 (~1OE), U402.13 (~2OE), U403.1 (~1OE), U403.13 (~2OE), U404.1 (~1OE), U404.13 (~2OE), U406.4
/FPGA_1V1: C401.1, C402.1, C403.1, C404.1, C405.1, C406.1, C407.1, C408.1, C409.1, C410.1, C411.1, C412.1, C413.1, C414.1, C415.1, C416.1, C417.1, C418.1, C419.1, C420.1, C421.1, C422.1, C423.1, TP404.1, U401.H8 (VCC), U401.H9 (VCC), U401.H10 (VCC), U401.H11 (VCC), U401.H12 (VCC), U401.H13 (VCC), U401.J8 (VCC), U401.J13 (VCC), U401.K8 (VCC), U401.K13 (VCC), U401.L8 (VCC), U401.L13 (VCC), U401.M8 (VCC), U401.M13 (VCC), U401.N8 (VCC), U401.N9 (VCC), U401.N10 (VCC), U401.N11 (VCC), U401.N12 (VCC), U401.N13 (VCC); also elsewhere on the board
/FPGA_2V5: FB401.1; also elsewhere on the board
/FPGA_3V3: C429.1, C430.1, C431.1, C432.1, C433.1, C434.1, C435.1, C436.1, C437.1, C438.1, C439.1, C440.1, C441.1, C442.1, C443.1, C444.1, C445.1, C446.1, C447.1, C448.1, C449.1, C450.1, C451.1, C452.1, C453.1, C454.1, C455.1, C456.1, C457.1, C458.1, C459.1, R401.1, R402.1, R403.1, R404.1, R406.1, R407.1, R408.1, R409.1, R410.1, R411.1, R412.1, R414.1, R418.1, TP406.1, U401.F9 (VCCIO0), U401.F10 (VCCIO0), U401.F11 (VCCIO1), U401.F12 (VCCIO1), U401.H6 (VCCIO7), U401.H7 (VCCIO7), U401.H14 (VCCIO2), U401.H15 (VCCIO2), U401.J6 (VCCIO7), U401.J15 (VCCIO2), U401.L6 (VCCIO6), U401.L7 (VCCIO6), U401.L14 (VCCIO3), U401.L15 (VCCIO3), U401.M6 (VCCIO6), U401.M15 (VCCIO3), U401.P9 (VCCIO8), U401.P10 (VCCIO8), U402.24 (VCC), U403.24 (VCC), U404.24 (VCC), U405.8 (VCC), U406.5 (VCC), U407.5 (VCC); also elsewhere on the board
/GND: C401.2, C402.2, C403.2, C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, C410.2, C411.2, C412.2, C413.2, C414.2, C415.2, C416.2, C417.2, C418.2, C419.2, C420.2, C421.2, C422.2, C423.2, C424.2, C425.2, C426.2, C427.2, C428.2, C429.2, C430.2, C431.2, C432.2, C433.2, C434.2, C435.2, C436.2, C437.2, C438.2, C439.2, C440.2, C441.2, C442.2, C443.2, C444.2, C445.2, C446.2, C447.2, C448.2, C449.2, C450.2, C451.2, C452.2, C453.2, C454.2, C455.2, C456.2, C457.2, C458.2, C459.2, D401.1 (K), R413.2, R415.2, R417.2, U401.B7 (GND), U401.B14 (GND), U401.C19 (GND), U401.D4 (GND), U401.F7 (GND), U401.F8 (GND), U401.F13 (GND), U401.F14 (GND), U401.G4 (GND), U401.G6 (GND), U401.G7 (GND), U401.G8 (GND), U401.G9 (GND), U401.G10 (GND), U401.G11 (GND), U401.G12 (GND), U401.G13 (GND), U401.G14 (GND), U401.G15 (GND), U401.G17 (GND), U401.H19 (GND), U401.J2 (GND), U401.J7 (GND), U401.J9 (GND), U401.J10 (GND), U401.J11 (GND), U401.J12 (GND), U401.J14 (GND), U401.K6 (GND), U401.K7 (GND), U401.K9 (GND), U401.K10 (GND), U401.K11 (GND), U401.K12 (GND), U401.K14 (GND), U401.K15 (GND), U401.L9 (GND), U401.L10 (GND), U401.L11 (GND), U401.L12 (GND), U401.M2 (GND), U401.M7 (GND), U401.M9 (GND), U401.M10 (GND), U401.M11 (GND), U401.M12 (GND), U401.M14 (GND), U401.M16 (GND), U401.N6 (GND), U401.N7 (GND), U401.N14 (GND), U401.N15 (GND), U401.P7 (GND), U401.P8 (GND), U401.P11 (GND), U401.P12 (GND), U401.P13 (GND), U401.P14 (GND), U401.R4 (CFG_2), U401.R19 (GND), U401.T6 (GND), U401.T7 (GND), U401.T8 (GND), U401.T9 (GND), U401.T10 (GND), U401.T11 (GND), U401.T12 (GND), U401.T13 (GND), U401.T14 (GND), U401.T15 (GND), U401.U4 (CFG_0), U401.U6 (GND), U401.U7 (GND), U401.U8 (GND), U401.U9 (GND), U401.U10 (GND), U401.U11 (GND), U401.U12 (GND), U401.U13 (GND), U401.U14 (GND), U401.U15 (GND), U401.V5 (GND), U401.V6 (GND), U401.V7 (GND), U401.V8 (GND), U401.V9 (GND), U401.V10 (GND), U401.V11 (GND), U401.V12 (GND), U401.V13 (GND), U401.V14 (GND), U401.V15 (GND), U401.V16 (GND), U401.V17 (GND), U401.V18 (GND), U401.V19 (GND), U401.V20 (GND), U401.W6 (GND), U401.W7 (GND), U401.W12 (GND), U401.W15 (GND), U401.W16 (GND), U401.W19 (GND), U401.W20 (GND), U401.Y5 (GND), U401.Y6 (GND), U401.Y7 (GND), U401.Y8 (GND), U401.Y11 (GND), U401.Y12 (GND), U401.Y14 (GND), U401.Y15 (GND), U401.Y16 (GND), U401.Y17 (GND), U401.Y19 (GND), U402.12 (GND), U403.12 (GND), U404.12 (GND), U405.4 (GND), U406.3 (GND), U407.3 (GND); also elsewhere on the board
/HOST_3V3: R416.1; also elsewhere on the board
/N64_AD0: U402.3 (1A1); also elsewhere on the board
/N64_AD1: U402.4 (1A2); also elsewhere on the board
/N64_AD2: U402.7 (1A3); also elsewhere on the board
/N64_AD3: U402.8 (1A4); also elsewhere on the board
/N64_AD4: U402.11 (1A5); also elsewhere on the board
/N64_AD5: U402.14 (2A1); also elsewhere on the board
/N64_AD6: U402.17 (2A2); also elsewhere on the board
/N64_AD7: U402.18 (2A3); also elsewhere on the board
/N64_AD8: U402.21 (2A4); also elsewhere on the board
/N64_AD9: U402.22 (2A5); also elsewhere on the board
/N64_AD10: U403.3 (1A1); also elsewhere on the board
/N64_AD11: U403.4 (1A2); also elsewhere on the board
/N64_AD12: U403.7 (1A3); also elsewhere on the board
/N64_AD13: U403.8 (1A4); also elsewhere on the board
/N64_AD14: U403.11 (1A5); also elsewhere on the board
/N64_AD15: U403.14 (2A1); also elsewhere on the board
/N64_ALE_H: U403.18 (2A3); also elsewhere on the board
/N64_ALE_L: U403.17 (2A2); also elsewhere on the board
/N64_CIC_CLK: U404.7 (1A3); also elsewhere on the board
/N64_CIC_DATA: U404.11 (1A5); also elsewhere on the board
/N64_INT_N: U404.17 (2A2); also elsewhere on the board
/N64_JOYBUS: U404.14 (2A1); also elsewhere on the board
/N64_NMI_N: U404.4 (1A2); also elsewhere on the board
/N64_PIF_CLK: U404.8 (1A4); also elsewhere on the board
/N64_READ_N: U403.21 (2A4); also elsewhere on the board
/N64_RESET_N: U404.3 (1A1); also elsewhere on the board
/N64_WRITE_N: U403.22 (2A5); also elsewhere on the board
/TARGET_VREF: R414.2; also elsewhere on the board
/adc_bck: U401.J4 (PL50A); also elsewhere on the board
/adc_dout: U401.K3 (PL50D); also elsewhere on the board
/adc_lrck: U401.J3 (PL50C); also elsewhere on the board
/board_reset_n: U401.L4 (PL56C); also elsewhere on the board
/cart_5v_enable: U401.L5 (PL56D); also elsewhere on the board
/cart_5v_ok: U401.H1 (PL53C); also elsewhere on the board
/cart_address0: U401.C18 (PR11A); also elsewhere on the board
/cart_address1: U401.D17 (PR11B); also elsewhere on the board
/cart_address2: U401.E16 (PR11C); also elsewhere on the board
/cart_address3: U401.F16 (PR11D); also elsewhere on the board
/cart_address4: U401.D18 (PR14A); also elsewhere on the board
/cart_address5: U401.E17 (PR14B); also elsewhere on the board
/cart_address6: U401.E18 (PR14C); also elsewhere on the board
/cart_address7: U401.F18 (PR14D); also elsewhere on the board
/cart_address8: U401.F17 (PR17A); also elsewhere on the board
/cart_address9: U401.G18 (PR17B); also elsewhere on the board
/cart_address10: U401.G16 (PR17C); also elsewhere on the board
/cart_address11: U401.H16 (PR17D); also elsewhere on the board
/cart_address12: U401.H18 (PR20A); also elsewhere on the board
/cart_address13: U401.H17 (PR20B); also elsewhere on the board
/cart_address14: U401.J17 (PR20C); also elsewhere on the board
/cart_address15: U401.J16 (PR20D); also elsewhere on the board
/cart_address16: U401.K16 (PR29A); also elsewhere on the board
/cart_address17: U401.K17 (PR29B); also elsewhere on the board
/cart_address18: U401.C20 (PR35A); also elsewhere on the board
/cart_address19: U401.D19 (PR35B); also elsewhere on the board
/cart_address20: U401.D20 (PR35C); also elsewhere on the board
/cart_address21: U401.E19 (PR35D); also elsewhere on the board
/cart_address22: U401.E20 (PR38A); also elsewhere on the board
/cart_address23: U401.F19 (PR38B); also elsewhere on the board
/cart_data0: U401.L16 (PR50A); also elsewhere on the board
/cart_data1: U401.L17 (PR50B); also elsewhere on the board
/cart_data2: U401.L18 (PR50C); also elsewhere on the board
/cart_data3: U401.M18 (PR50D); also elsewhere on the board
/cart_data4: U401.N16 (PR53A); also elsewhere on the board
/cart_data5: U401.M17 (PR53B); also elsewhere on the board
/cart_data6: U401.N18 (PR53C); also elsewhere on the board
/cart_data7: U401.P17 (PR53D); also elsewhere on the board
/cart_irq_n: U401.T18 (PR89D); also elsewhere on the board
/cart_pa0: U401.F20 (PR38C); also elsewhere on the board
/cart_pa1: U401.G20 (PR38D); also elsewhere on the board
/cart_pa2: U401.G19 (PR41A); also elsewhere on the board
/cart_pa3: U401.H20 (PR41B); also elsewhere on the board
/cart_pa4: U401.J18 (PR41C); also elsewhere on the board
/cart_pa5: U401.K18 (PR41D); also elsewhere on the board
/cart_pa6: U401.J19 (PR44A); also elsewhere on the board
/cart_pa7: U401.K19 (PR44B); also elsewhere on the board
/cart_phi2: U401.M20 (PR47B); also elsewhere on the board
/cart_prd_n: U401.P16 (PR56B); also elsewhere on the board
/cart_pwr_n: U401.R16 (PR56C); also elsewhere on the board
/cart_rd_n: U401.M19 (PR47D); also elsewhere on the board
/cart_refresh: U401.L19 (PR47C); also elsewhere on the board
/cart_reset_n_sense: U401.U18 (PR92A); also elsewhere on the board
/cart_reset_pull_n: U401.U19 (PR89C); also elsewhere on the board
/cart_romsel_n: U401.R17 (PR56D); also elsewhere on the board
/cart_sysclk: U401.L20 (PR47A); also elsewhere on the board
/cart_wr_n: U401.N17 (PR56A); also elsewhere on the board
/cart_wramsel_n: U401.T16 (PR77A); also elsewhere on the board
/cic_clk: U401.P20 (PR86A); also elsewhere on the board
/cic_data0: U401.T20 (PR86C); also elsewhere on the board
/cic_data0_dir: U401.U20 (PR86D); also elsewhere on the board
/cic_data1: U401.T19 (PR89A); also elsewhere on the board
/cic_data1_dir: U401.R18 (PR89B); also elsewhere on the board
/cic_oe_n: U401.P18 (PR83D); also elsewhere on the board
/cic_slave_reset: U401.R20 (PR86B); also elsewhere on the board
/ctl_oe_n: U401.N19 (PR83A); also elsewhere on the board
/data_dir: U401.P19 (PR83C); also elsewhere on the board
/data_oe_n: U401.N20 (PR83B); also elsewhere on the board
/efuse_fault_n: U401.K4 (PL56A); also elsewhere on the board
/expand_sense: U401.U17 (PR92B); also elsewhere on the board
/fpga_rails_ok: R415.1, U401.J1 (PL53B), U407.2; also elsewhere on the board
/host_3v3_ok: U401.K2 (PL53A); also elsewhere on the board
/iface_rail_enable: U401.M5 (PL77A); also elsewhere on the board
/iface_rail_ok: U401.K1 (PL53D); also elsewhere on the board
/jtag_tck: R413.1, U401.T5 (TCK); also elsewhere on the board
/jtag_tdi: R410.2, U401.R5 (TDI); also elsewhere on the board
/jtag_tdo: R412.2, U401.V4 (TDO); also elsewhere on the board
/jtag_tms: R411.2, U401.U5 (TMS); also elsewhere on the board
/osc_25: U401.G2 (PL47A); also elsewhere on the board
/overtemp: U401.K5 (PL56B); also elsewhere on the board
/si_clk0: U401.H2 (PL47C); also elsewhere on the board
/si_clk1: U401.G3 (PL44A); also elsewhere on the board
/si_scl: U401.E4 (PL17A); also elsewhere on the board
/si_sda: U401.F4 (PL20A); also elsewhere on the board

Notes on the sheet:
SN64 FPGA - LFE5U-85F CABGA381, CONFIGURATION FLASH, JTAG, N64 HOST ISOLATION
Rails: VCC = FPGA_1V1 (1.1 V, DS-02012 Table 3.2), VCCAUX = FPGA_2V5 through FB401 (TN-02038 Figure 3.1), every VCCIO0/1/2/3/6/7/8 = FPGA_3V3. Bank plan: 0 = N64 PI/CIC/SI behind the bus switches (top bank, hot-socket capable), 1 = spare (HDMI removed in 0.5-fpga: video goes to the console over the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
Configuration: CFG[2:0] = 010 Master SPI (CFG0/CFG2 to GND, CFG1 4.7k to VCCIO8). PROGRAMN/INITN/DONE 4.7k to VCCIO8 (TN-02038 Table 6.2). U307 holds PROGRAMN low until fpga_rails_ok (DS-02012 3.5: MSPI needs VCCIO8 above the flash VIH before VCC/VCCAUX reach VPORUP, or PROGRAMN/INITN held low). U4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
N64 HOST ISOLATION: U402-U404 SN74CB3Q3384A FET bus switches (A = N64 edge, B = FPGA bank 0), VCC = FPGA_3V3. OE = NOT(HOST_3V3 present): U406 Schmitt inverter on the R416/R417 divider. USB-only (HOST_3V3 absent): OE high, switch off. FPGA_3V3 absent: switch unpowered, "isolation during power off" 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
DRAFT 0.5-fpga: schematic only - no PCB, no SI or power-integrity analysis, no hardware test. FPGA_1V1/2V5/3V3 come from the power sheet (its #FLG302-#FLG304 are their ERC origins). #FLG404 marks FPGA_VCCAUX, fed only through FB401. Pin map: interfaces/fpga-pin-map.csv; constraints: fpga/constraint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

Schematic: power.kicad_sch, SN 64 - Power

Parts:
C301, C311, C333, C334, C335, C336, C337, C338, C339, C340: 100nF; C_0603_1608Metric
C302, C305: 1.5nF 25V; C_0603_1608Metric
C303, C306, C309: 1.2nF; C_0603_1608Metric
C304, C307, C310: 1uF 25V; C_0805_2012Metric
C308: 680pF 25V; C_0603_1608Metric
C312, C313: 10uF 25V; C_0805_2012Metric
C314, C315: 22uF 25V; C_1206_3216Metric
C316, C317, C318, C320, C321, C322, C324, C325, C326, C328, C329, C330: 22uF 10V; C_0805_2012Metric
C319, C323, C327: 6.8pF C0G; C_0603_1608Metric
C331: 470pF 25V C0G; C_0603_1608Metric
C332: 1uF 10V; C_0603_1608Metric
L301: 1.5uH PNR4020-1R5M; L_APV_PNR4020; MPN PNR4020-1R5M; LCSC C54620133
L302, L303, L304: 2.2uH FNR4030S2R2MT; L_Changjiang_FNR4030S; MPN FNR4030S2R2MT; LCSC C167869
Q301, Q302, Q303, Q304, Q305, Q306, Q307, Q308: BSS138BK; SOT-23; MPN BSS138BK,215; LCSC C282529
R301: 887k 1%; R_0603_1608Metric
R302, R303, R304, R305, R306, R322, R323, R324, R325, R327, R333: 100k; R_0603_1608Metric
R307: 267k 1%; R_0603_1608Metric
R308, R310, R313, R315, R318, R320, R365: 100k 1%; R_0603_1608Metric
R309: 383k 1%; R_0603_1608Metric
R311: 2.55k 1%; R_0603_1608Metric
R312: 150k 1%; R_0603_1608Metric
R314: 215k 1%; R_0603_1608Metric
R316: 6.65k 1%; R_0603_1608Metric
R317: 287k 1%; R_0603_1608Metric
R319: 357k 1%; R_0603_1608Metric
R321: 3.32k 1%; R_0603_1608Metric
R326, R340: 1k; R_0603_1608Metric
R328: 470 0805; R_0805_2012Metric
R329, R360, R361, R362, R363, R366, R368: 10k; R_0603_1608Metric
R331, R357: 232k 0.1%; R_0603_1608Metric
R332, R356: 44.2k 0.1%; R_0603_1608Metric
R334: 100k 0.1%; R_0603_1608Metric
R335: 120k 0.1%; R_0603_1608Metric
R336: 361k 0.1%; R_0603_1608Metric
R337: 114k 0.1%; R_0603_1608Metric
R338: 459k 0.1%; R_0603_1608Metric
R339: 102k 0.1%; R_0603_1608Metric
R341: 100; R_0603_1608Metric
R342: 442k 0.1%; R_0603_1608Metric
R343: 37.4k 0.1%; R_0603_1608Metric
R344: 33.6k 0.1%; R_0603_1608Metric
R345: 115k 0.1%; R_0603_1608Metric
R346: 3.74k 0.1%; R_0603_1608Metric
R347: 64.2k 0.1%; R_0603_1608Metric
R348: 287k 0.1%; R_0603_1608Metric
R349: 3.16k 0.1%; R_0603_1608Metric
R350: 53.0k 0.1%; R_0603_1608Metric
R351: 277k 0.1%; R_0603_1608Metric
R352: 2.37k 0.1%; R_0603_1608Metric
R353: 37.0k 0.1%; R_0603_1608Metric
R354: 530k 0.1%; R_0603_1608Metric
R355: 3.79k 0.1%; R_0603_1608Metric
R358: 5.05k 0.1%; R_0603_1608Metric
R359: 30.1k 0.1%; R_0603_1608Metric
R364: 649k 1%; R_0603_1608Metric
R367: 47k; R_0603_1608Metric
TP301: SYS_VIN; TestPoint_Pad_D1.0mm
TP302: USB_FLT_N; TestPoint_Pad_D1.0mm
TP303: HOST_FLT_N; TestPoint_Pad_D1.0mm
TP304: HOST_AUXOFF; TestPoint_Pad_D1.0mm
TP305: CART_AUXOFF; TestPoint_Pad_D1.0mm
TP306: TC_OUT2; TestPoint_Pad_D1.0mm
TP307: 5V_PRE; TestPoint_Pad_D1.0mm
TP308: SNES_5V_CART; TestPoint_Pad_D1.0mm
TP309: USB_AUXOFF; TestPoint_Pad_D1.0mm
TP310: ILM_U309; TestPoint_Pad_D1.0mm
U301: TUSB320IRWBR; Texas_X2QFN-12_1.6x1.6mm_P0.4mm; LCSC C80170
U302, U303, U309: TPS259470LRPWR; Texas_RPW0010A_VQFN-HR-10_2x2mm; LCSC C3662793
U304: TPS63070RNMR; Texas_RNM0015A_VQFN-HR-15_2.5x3mm; LCSC C109322
U305, U306, U307: TLV62569DBVR; SOT-23-5; LCSC C141836
U308: TPS22918DBVR; SOT-23-6; LCSC C131941
U310, U311, U312, U313, U314, U315: TPS3700DDCR; SOT-23-6; LCSC C33002
U316: TPS3808G01DBVR; SOT-23-6; LCSC C19653
U317: TMP302ADRLR; SOT-563; LCSC C2877557

Connections:
/5V_PRE: C310.1, C316.1, C317.1, C318.1, C320.1, C324.1, C328.1, R317.1, R319.1, R327.1, R331.1, R333.1, TP307.1, U304.7 (VOUT), U304.8 (VOUT), U305.4 (VIN), U306.4 (VIN), U307.4 (VIN), U309.5 (IN); also elsewhere on the board
/FPGA_1V1: C319.1, C321.1, C322.1, L302.2, R334.1, R345.1; also elsewhere on the board
/FPGA_2V5: C323.1, C325.1, C326.1, L303.2, R336.1, R348.1; also elsewhere on the board
/FPGA_3V3: C327.1, C329.1, C330.1, C332.1, C333.1, C334.1, C335.1, C336.1, C337.1, C338.1, C339.1, C340.1, L304.2, R325.1, R329.1, R338.1, R351.1, R360.1, R361.1, R362.1, R363.1, R364.1, R366.1, R367.1, R368.1, U308.1 (VIN), U310.5 (VDD), U311.5 (VDD), U312.5 (VDD), U313.5 (VDD), U314.5 (VDD), U315.5 (VDD), U316.6 (VDD), U317.1 (TRIPSET0), U317.4 (HYSTSET), U317.5 (VS), U317.6 (TRIPSET1); also elsewhere on the board
/GND: C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C320.2, C321.2, C322.2, C324.2, C325.2, C326.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C337.2, C338.2, C339.2, C340.2, Q301.2 (S), Q302.2 (S), Q303.2 (S), Q304.2 (S), Q305.2 (S), Q306.2 (S), Q307.2 (S), Q308.2 (S), R308.2, R310.2, R311.2, R313.2, R315.2, R316.2, R318.2, R320.2, R321.2, R326.2, R332.2, R335.2, R337.2, R339.2, R340.2, R344.2, R347.2, R350.2, R353.2, R356.2, R359.2, R365.2, U301.3 (PORT), U301.10 (GND), U301.11 (~EN), U302.8 (GND), U303.8 (GND), U304.1 (PS/SYNC), U304.4 (GND), U304.10 (PGND), U304.15 (VSEL), U305.2 (GND), U306.2 (GND), U307.2 (GND), U308.2 (GND), U309.8 (GND), U310.2 (GND), U311.2 (GND), U312.2 (GND), U313.2 (GND), U314.2 (GND), U315.2 (GND), U316.2 (GND), U317.2 (GND); also elsewhere on the board
/HOST_3V3: C307.1, R312.1, R314.1, R323.1, R324.1, U303.5 (IN); also elsewhere on the board
/INTERFACE_3V3: R341.2, R357.1, U308.6 (VOUT); also elsewhere on the board
/Power/CART_AUXOFF: R325.2, TP305.1, U309.3 (AUXOFF)
/Power/CART_DIS: Q307.3 (D), R328.2
/Power/CART_EN: Q306.3 (D), R317.2, R318.1, U309.1 (EN/UVLO)
/Power/CART_INHIBIT: Q305.3 (D), Q306.1 (G), Q307.1 (G), R327.2
/Power/CART_OVLO: R319.2, R320.1, U309.2 (OVLO)
/Power/CT_IFACE: C331.1, U308.4 (CT)
/Power/DVDT_U302: C302.1, U302.7 (DVDT)
/Power/DVDT_U303: C305.1, U303.7 (DVDT)
/Power/DVDT_U309: C308.1, U309.7 (DVDT)
/Power/FB_1V1: C319.2, R334.2, R335.1, U305.5 (FB)
/Power/FB_2V5: C323.2, R336.2, R337.1, U306.5 (FB)
/Power/FB_3V3: C327.2, R338.2, R339.1, U307.5 (FB)
/Power/FB_5V: R331.2, R332.1, U304.5 (FB)
/Power/HOST_AUXOFF: R324.2, TP304.1, U303.3 (AUXOFF)
/Power/HOST_EN: Q304.3 (D), R312.2, R313.1, U303.1 (EN/UVLO)
/Power/HOST_FLT_N: R323.2, TP303.1, U303.4 (~FLT)
/Power/HOST_OVLO: R314.2, R315.1, U303.2 (OVLO)
/Power/ILM_U302: R311.1, U302.9 (ILM)
/Power/ILM_U303: R316.1, U303.9 (ILM)
/Power/ILM_U309: R321.1, TP310.1, U309.9 (ILM)
/Power/ITIMER_U302: C303.1, U302.10 (ITIMER)
/Power/ITIMER_U303: C306.1, U303.10 (ITIMER)
/Power/ITIMER_U309: C309.1, U309.10 (ITIMER)
/Power/L1_5V: L301.1, U304.11 (L1)
/Power/L2_5V: L301.2, U304.9 (L2)
/Power/MON_A_U310: R342.2, R343.1, U310.3 (INA+)
/Power/MON_A_U311: R345.2, R346.1, U311.3 (INA+)
/Power/MON_A_U312: R348.2, R349.1, U312.3 (INA+)
/Power/MON_A_U313: R351.2, R352.1, U313.3 (INA+)
/Power/MON_A_U314: R354.2, R355.1, U314.3 (INA+)
/Power/MON_A_U315: R357.2, R358.1, U315.3 (INA+)
/Power/MON_B_U310: R343.2, R344.1, U310.4 (INB-)
/Power/MON_B_U311: R346.2, R347.1, U311.4 (INB-)
/Power/MON_B_U312: R349.2, R350.1, U312.4 (INB-)
/Power/MON_B_U313: R352.2, R353.1, U313.4 (INB-)
/Power/MON_B_U314: R355.2, R356.1, U314.4 (INB-)
/Power/MON_B_U315: R358.2, R359.1, U315.4 (INB-)
/Power/OT_N: Q308.1 (G), R367.2, U317.3 (~OUT)
/Power/PG_5V: R333.2, U304.2 (PG), U305.1 (EN), U306.1 (EN), U307.1 (EN)
/Power/QOD_IFACE: R341.1, U308.5 (QOD)
/Power/SENSE_3V3: R364.2, R365.1, U316.5 (SENSE)
/Power/SW_1V1: L302.1, U305.3 (SW)
/Power/SW_2V5: L303.1, U306.3 (SW)
/Power/SW_3V3: L304.1, U307.3 (SW)
/Power/SYS_VIN: C312.1, C313.1, C314.1, C315.1, R342.1, TP301.1, U302.6 (OUT), U303.6 (OUT), U304.12 (VIN), U304.13 (VIN), U304.14 (EN)
/Power/TC_OUT1: Q301.1 (G), R302.2, U301.7 (SDA/OUT1)
/Power/TC_OUT2: R303.2, TP306.1, U301.8 (SCL/OUT2)
/Power/USB_AUXOFF: Q304.1 (G), R306.2, TP309.1, U302.3 (AUXOFF)
/Power/USB_EN: Q303.3 (D), R307.2, R308.1, U302.1 (EN/UVLO)
/Power/USB_FLT_N: R322.2, TP302.1, U302.4 (~FLT)
/Power/USB_INHIBIT: Q302.3 (D), Q303.1 (G), R305.2
/Power/USB_OVLO: R309.2, R310.1, U302.2 (OVLO)
/Power/USB_PERMIT: Q301.3 (D), Q302.1 (G), R304.2
/Power/VAUX_5V: C311.1, U304.3 (VAUX)
/Power/VBUS_DET: R301.2, U301.4 (VBUS_DET)
/SNES_5V_CART: R328.1, R354.1, TP308.1, U309.6 (OUT); also elsewhere on the board
/USB_3V3: C301.1, R302.1, R303.1, R304.1, R306.1, R322.1, U301.12 (VDD); also elsewhere on the board
/USB_CC1: U301.1 (CC1); also elsewhere on the board
/USB_CC2: U301.2 (CC2); also elsewhere on the board
/USB_VBUS: C304.1, R301.1, R305.1, R307.1, R309.1, U302.5 (IN); also elsewhere on the board
/board_reset_n: R366.2, U316.1 (~RESET); also elsewhere on the board
/cart_5v_enable: Q305.1 (G), R326.1; also elsewhere on the board
/cart_5v_ok: R362.2, U314.1 (OUTA), U314.6 (OUTB); also elsewhere on the board
/efuse_fault_n: R329.2, U309.4 (~FLT); also elsewhere on the board
/fpga_rails_ok: R361.2, U311.1 (OUTA), U311.6 (OUTB), U312.1 (OUTA), U312.6 (OUTB), U313.1 (OUTA), U313.6 (OUTB), U316.3 (~MR); also elsewhere on the board
/host_3v3_ok: R360.2, U310.1 (OUTA), U310.6 (OUTB); also elsewhere on the board
/iface_rail_enable: R340.1, U308.3 (ON); also elsewhere on the board
/iface_rail_ok: R363.2, U315.1 (OUTA), U315.6 (OUTB); also elsewhere on the board
/overtemp: Q308.3 (D), R368.2; also elsewhere on the board

Notes on the sheet:
SN64 POWER - source selection, system regulator, FPGA rails, cartridge eFuse, interface rail, monitors
Implements docs/design/power-architecture.md; math and sources in docs/design/power-schematic.md. HOST_12V is not used on this sheet. Priority power mux (TI SLVSFC9C Figure 8-14): U302 (USB, priority) AUXOFF -> Q304 pulls U303 (HOST_3V3, auxiliary) EN/UVLO low. Both eFuses have true reverse-current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
USB permission (default off): U302 enables only when TUSB320 OUT1 is low (1.5 A or 3 A advertised) AND USB_3V3 is present. TUSB320: PORT=GND (UFP), ADDR open (GPIO mode), EN_N=GND, VDD=USB_3V3 (power register PWR-L06). The USB sheet 5.1k Rd must be DNP.
SYSTEM REGULATOR: U304 TPS63070 buck-boost (forced PWM, +/-1% FB), SYS_VIN 2.7-6 V -> 5V_PRE 5.00 V. PG_5V enables the three TLV62569 bucks. ECP5: VCCIO8 must be valid before VCC/VCCAUX reach POR, or PROGRAMN/INITN held low (FPGA-DS-02012 3.4 sec. 3.5): fpga_rails_ok gates PROGRAMN on the FPGA shee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
CARTRIDGE 5 V: U309 TPS259470L, EN/UVLO default low (Q306 clamp until cart_5v_enable), UVLO 4.64 V / OVLO 5.48 V rising, ILIM 1.00 A (PROV), dVdt 680 pF (PROV), ITIMER 1.2 nF. Q307 + R328 470R discharge while inhibited (<=12 mA into an energized rail). INTERFACE_3V3: U308 TPS22918, ON default low (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
MONITORS (all powered from FPGA_3V3, outputs pulled up to FPGA_3V3 = 3.3 V-safe; supply loss reads NOT OK): U310 SYS_VIN -> host_3v3_ok | U311-U313 FPGA rails -> fpga_rails_ok | U314 SNES_5V_CART (socket side) -> cart_5v_ok | U315 INTERFACE_3V3 -> iface_rail_ok | U309 FLT (10k to FPGA_3V3) -> efuse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
DRAFT 0.1-power: schematic candidate only. No PCB, no measured load. Values marked PROV depend on unmeasured cartridge and FPGA current. Footprints for U302/U303/U309 (RPW0010A), U304 (RNM0015A) and L301 (PNR4020) are drawn from the manufacturer land patterns by tools/make_power_footprints.py; L302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
